# IAR project MSM_952.ewp, settings and files
configuration Debug (78000, debug)
  General.GHeapSize: 512
  General.GFarHeapSize: 4096
  General.GeneralDeviceSelect: 78F1833_64 78K0R - uPD78F1833_64
  ICC78000.CCDefines: __DEBUG__; __PIN_DEBUG__; __ON_CHIP_DEBUG__
  ICC78000.CCIncludePath2: ..\PTFC_Core; ..\PTFC_Core\Driver; ..\PTFC_Core\Driver\ADCD; ..\PTFC_Core\Driver\CAND; ..\PTFC_Core\Driver\DIOD; ..\PTFC_Core\Driver\ISRD; ..\PTFC_Core\Driver\MEMD; ..\PTFC_Core\Driver\UARTD; ..\PTFC_Core\Control; ..\PTFC_Core\Control\ADCC; ..\PTFC_Core\Control\EEPC; ..\PTFC_Core\Control\DIAC; ..\PTFC_Core\Control\MUXC; ..\PTFC_Core\Control\DOIFC; ..\PTFC_Core\Control\DOVFC; ..\PTFC_Core\Control\DIAGC; ..\PTFC_Core\Control\HBRGC; ..\PTFC_Core\Control\IPOC; ..\PTFC_Core\Control\LINC; ..\PTFC_Core\Control\PWMC; ..\PTFC_Core\Presentation; ..\PTFC_Core\Presentation\AVGP; ..\PTFC_Core\Presentation\DDMP; ..\PTFC_Core\Presentation\DINP; ..\PTFC_Core\Presentation\EEPP; ..\PTFC_Core\Presentation\FUNP; ..\PTFC_Core\Presentation\FVMP; ..\PTFC_Core\Presentation\LINP; ..\PTFC_Core\Presentation\NETP; ..\PTFC_Core\Presentation\TLRP; ..\PTFC_Core\Presentation\TP; ..\PTFC_Core\Presentation\MOTP; ..\PTFC_Core\Presentation\SNSP; ..\PTFC_Core\System; ..\PTFC_Core\System\LPMS; ..\PTFC_Core\System\LTMS; ..\PTFC_Core\System\Scheduler; ..\PTFC_Core\System\TASK; ..\PTFC_Cfg; ..\PTFC_Cfg\Driver; ..\PTFC_Cfg\Driver\ADCD; ..\PTFC_Cfg\Driver\CAND; ..\PTFC_Cfg\Driver\CMMD; ..\PTFC_Cfg\Driver\DIOD; ..\PTFC_Cfg\Driver\MEMD; ..\PTFC_Cfg\Driver\UARTD; ..\PTFC_Cfg\Control; ..\PTFC_Cfg\Control\ADCC; ..\PTFC_Cfg\Control\DIAC; ..\PTFC_Cfg\Control\DOIFC; ..\PTFC_Cfg\Control\DOVFC; ..\PTFC_Cfg\Control\DIAGC; ..\PTFC_Cfg\Control\EEPC; ..\PTFC_Cfg\Control\HBRGC; ..\PTFC_Cfg\Control\IPOC; ..\PTFC_Cfg\Control\LINC; ..\PTFC_Cfg\Control\MUXC; ..\PTFC_Cfg\Control\PWMC; ..\PTFC_Cfg\Presentation; ..\PTFC_Cfg\Presentation\AVGP; ..\PTFC_Cfg\Presentation\DDMP; ..\PTFC_Cfg\Presentation\DINP; ..\PTFC_Cfg\Presentation\EEPP; ..\PTFC_Cfg\Presentation\FUNP; ..\PTFC_Cfg\Presentation\FVMP; ..\PTFC_Cfg\Presentation\LINP; ..\PTFC_Cfg\Presentation\MOTP; ..\PTFC_Cfg\Presentation\SNSP; ..\PTFC_Cfg\Presentation\NETP; ..\PTFC_Cfg\Presentation\TLRP; ..\PTFC_Cfg\Presentation\TP; ..\PTFC_Cfg\System; ..\PTFC_Cfg\System\ECUIDS; ..\PTFC_Cfg\System\LPMS; ..\PTFC_Cfg\System\LTMS; ..\PTFC_Cfg\System\SCHDS; ..\PTFC_Cfg\System\TASK; ..\PTFC_Cfg\MCAL; ..\PTFC_Cfg\MCAL\FE78K0R_CG; ..\APPL_Core; ..\APPL_Core\APSA; ..\APPL_Core\DISPA; ..\APPL_Core\EXMMA; ..\APPL_Core\FANA; ..\APPL_Core\KEYA; ..\APPL_Core\MOTA; ..\APPL_Core\NWMA; ..\APPL_Core\UDSA; ..\APPL_Core\SSMA; ..\APPL_Core\VF607; ..\APPL_Core\VF608; ..\APPL_Cfg; ..\APPL_Cfg\DISPA; ..\APPL_Cfg\EXMMA; ..\APPL_Cfg\FANA; ..\APPL_Cfg\KEYA; ..\APPL_Cfg\NWMA; ..\APPL_Cfg\UDSA; ..\APPL_Cfg\SSMA; ..\APPL_Core\HEATA; ..\APPL_Cfg\HEATA; ..\APPL_Cfg\VF607; ..\APPL_Cfg\VF608
  ICC78000.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC78000.CCOptLevel: 3
  ICC78000.CCOptStrategy: 2
  A78000.ADefines: __FAR_MODEL__; __NEAR_DATA_MODEL__; __DEBUG__
  A78000.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: xcl\lnk78f1833_64_applDbgMsm952.xcl
  XLINK.XlinkStackSize: 1
configuration Release (78000)
  as the first configuration, except:
  ICC78000.CCOptStrategy: 0
  A78000.ADefines: __FAR_MODEL__; __NEAR_DATA_MODEL__
  XLINK.XclFile: xcl\lnk78f1833_64_applRelMsm952.xcl
  group APPL_Cfg
    ../APPL_Cfg/: APPL_cfg.h
  group APPL_Cfg/DISPA
    ../APPL_Cfg/DISPA/: DISPA_cbk.h DISPA_cfgIf.h DISPA_config.c DISPA_config.h
  group APPL_Cfg/EXMMA
    ../APPL_Cfg/EXMMA/: EXMMA_cbk.h EXMMA_config.c EXMMA_config.h
  group APPL_Cfg/FANA
    ../APPL_Cfg/FANA/: FANA_cfgIf.h FANA_config.c FANA_config.h
  group APPL_Cfg/HEATA
    ../APPL_Cfg/HEATA/: HEATA_cbk.h HEATA_cfgIf.h HEATA_config.c HEATA_config.h
  group APPL_Cfg/KEYA
    ../APPL_Cfg/KEYA/: KEYA_cbk.h KEYA_config.c KEYA_config.h
  group APPL_Cfg/NWMA
    ../APPL_Cfg/NWMA/: NWMA_cbk.h NWMA_cfgIf.h NWMA_config.c NWMA_config.h
  group APPL_Cfg/SSMA
    ../APPL_Cfg/SSMA/: SSMA_cbk.h SSMA_config.c SSMA_config.h
  group APPL_Cfg/UDSA
    ../APPL_Cfg/UDSA/: UDSA_cbk.h UDSA_cfgIf.h UDSA_config.c UDSA_config.h UDSA_DtcConfig.c UDSA_IocConfig.c UDSA_RdiConfig.c UDSA_RtnConfig.c
  group APPL_Cfg/VF607
    ../APPL_Cfg/VF607/: VF607_cbk.h
  group APPL_Cfg/VF608
    ../APPL_Cfg/VF608/: VF608_cbk.h
  group APPL_Core
    ../APPL_Core/: APPL.c APPL_if.h APPL_typedefs.h
  group APPL_Core/APSA
    ../APPL_Core/APSA/: APSA.c APSA.h APSA_Config.h tl_basetypes.h tl_defines_APSA.h tl_types.h
  group APPL_Core/DISPA
    ../APPL_Core/DISPA/: DISPA.c DISPA.h DISPA_if.h
  group APPL_Core/EXMMA
    ../APPL_Core/EXMMA/: EXMMA.c EXMMA.h EXMMA_if.h
  group APPL_Core/FANA
    ../APPL_Core/FANA/: FANA.c FANA.h FANA_if.h
  group APPL_Core/HEATA
    ../APPL_Core/HEATA/: HEATA.c HEATA.h HEATA_if.h
  group APPL_Core/KEYA
    ../APPL_Core/KEYA/: KEYA.c KEYA.h KEYA_if.h
  group APPL_Core/MOTA
    ../APPL_Core/MOTA/: MOTA.c MOTA.h MOTA_Define.h tl_basetypes.h tl_define.h tl_types.h
  group APPL_Core/NWMA
    ../APPL_Core/NWMA/: NWMA.c NWMA.h NWMA_if.h
  group APPL_Core/SSMA
    ../APPL_Core/SSMA/: SSMA.c SSMA.h SSMA_if.h
  group APPL_Core/UDSA
    ../APPL_Core/UDSA/: UDSA.c UDSA.h UDSA_if.h
  group APPL_Core/VF607
    ../APPL_Core/VF607/: VF607.c VF607.h VF607_if.h
  group APPL_Core/VF608
    ../APPL_Core/VF608/: VF608.c VF608.h VF608_if.h
  group PTFC_Cfg
    ../PTFC_Cfg/: global_config.h
  group PTFC_Cfg/Control
    ../PTFC_Cfg/Control/: CTRL_cfg.h
  group PTFC_Cfg/Control/ADCC
    ../PTFC_Cfg/Control/ADCC/: ADCC_cfgIf.h ADCC_config.c ADCC_config.h
  group PTFC_Cfg/Control/DIAC
    ../PTFC_Cfg/Control/DIAC/: DIAC_cfgIf.h DIAC_config.c DIAC_config.h
  group PTFC_Cfg/Control/DIAGC
    ../PTFC_Cfg/Control/DIAGC/: DIAGC_cfgIf.h DIAGC_config.c DIAGC_config.h
  group PTFC_Cfg/Control/DOIFC
    ../PTFC_Cfg/Control/DOIFC/: DOIFC_cfgIf.h DOIFC_config.c DOIFC_config.h
  group PTFC_Cfg/Control/DOVFC
    ../PTFC_Cfg/Control/DOVFC/: DOVFC_cfgIf.h DOVFC_config.c DOVFC_config.h
  group PTFC_Cfg/Control/EEPC
    ../PTFC_Cfg/Control/EEPC/: EEPC_cfgIf.h EEPC_config.c EEPC_config.h
  group PTFC_Cfg/Control/HBRGC
    ../PTFC_Cfg/Control/HBRGC/: HBRGC_cfgIf.h HBRGC_config.c HBRGC_config.h
  group PTFC_Cfg/Control/IPOC
    ../PTFC_Cfg/Control/IPOC/: IPOC_cfgIf.h IPOC_config.c IPOC_config.h
  group PTFC_Cfg/Control/LINC
    ../PTFC_Cfg/Control/LINC/: LINC_cbk.h LINC_cfgIf.h LINC_config.c LINC_config.h
  group PTFC_Cfg/Control/MUXC
    ../PTFC_Cfg/Control/MUXC/: MUXC_cfgIf.h MUXC_config.c MUXC_config.h
  group PTFC_Cfg/Control/PWMC
    ../PTFC_Cfg/Control/PWMC/: PWMC_cbk.h PWMC_cfgIf.h PWMC_config.c PWMC_config.h
  group PTFC_Cfg/Driver
    ../PTFC_Cfg/Driver/: DRVD_cfg.h
  group PTFC_Cfg/Driver/ADCD
    ../PTFC_Cfg/Driver/ADCD/: ADCD_cfgIf.h ADCD_config.c ADCD_config.h
  group PTFC_Cfg/Driver/CAND
    ../PTFC_Cfg/Driver/CAND/: CAND_CfgIf.h CAND_config.c CAND_config.h
  group PTFC_Cfg/Driver/CMMD
    ../PTFC_Cfg/Driver/CMMD/: CMMD_cfgIf.h CMMD_config.c
  group PTFC_Cfg/Driver/DIOD
    ../PTFC_Cfg/Driver/DIOD/: DIOD_cfgIf.h DIOD_config.c DIOD_config.h
  group PTFC_Cfg/Driver/MEMD
    ../PTFC_Cfg/Driver/MEMD/: MEMD_cfgIf.h MEMD_config.c MEMD_config.h
  group PTFC_Cfg/Driver/UARTD
    ../PTFC_Cfg/Driver/UARTD/: UARTD_cfgIf.h UARTD_config.c UARTD_config.h
  group PTFC_Cfg/MCAL
    ../PTFC_Cfg/MCAL/: io78f1833_64.h io78f1833_64_ext.h io78f18xx_Eclipse.h
  group PTFC_Cfg/MCAL/FE78K0R_CG
    ../PTFC_Cfg/MCAL/FE78K0R_CG/: FE78K0R_CG_int.c FE78K0R_CG_int.h FE78K0R_CG_int_user.c FE78K0R_CG_int_user.h FE78K0R_CG_macrodriver.h FE78K0R_CG_port.c FE78K0R_CG_port.h FE78K0R_CG_serial.c FE78K0R_CG_serial.h FE78K0R_CG_serial_user.c FE78K0R_CG_system.c FE78K0R_CG_system.h FE78K0R_CG_system_user.c FE78K0R_CG_systeminit.c FE78K0R_CG_timer.c FE78K0R_CG_timer.h FE78K0R_CG_timer_user.c FE78K0R_CG_timer_user.h FE78K0R_CG_wdt.c FE78K0R_CG_wdt.h MCAL.h MCAL_if.h
  group PTFC_Cfg/Presentation
    ../PTFC_Cfg/Presentation/: PRES_cfg.h
  group PTFC_Cfg/Presentation/AVGP
    ../PTFC_Cfg/Presentation/AVGP/: AVGP_cfgIf.h AVGP_config.c AVGP_config.h
  group PTFC_Cfg/Presentation/DDMP
    ../PTFC_Cfg/Presentation/DDMP/: DDMP_cbk.h DDMP_cfgIf.h DDMP_config.c DDMP_config.h
  group PTFC_Cfg/Presentation/DINP
    ../PTFC_Cfg/Presentation/DINP/: DINP_cfgIf.h DINP_config.c DINP_config.h
  group PTFC_Cfg/Presentation/EEPP
    ../PTFC_Cfg/Presentation/EEPP/: EEPP_cfgIf.h EEPP_config.c EEPP_config.h
  group PTFC_Cfg/Presentation/FUNP
    ../PTFC_Cfg/Presentation/FUNP/: FUNP_cbk.h FUNP_cfgIf.h FUNP_config.c FUNP_config.h
  group PTFC_Cfg/Presentation/FVMP
    ../PTFC_Cfg/Presentation/FVMP/: FVMP_cbk.h FVMP_cfgIf.h FVMP_config.c FVMP_config.h
  group PTFC_Cfg/Presentation/LINP
    ../PTFC_Cfg/Presentation/LINP/: LINP_cbk.h LINP_cfgIf.h LINP_config.c LINP_config.h
  group PTFC_Cfg/Presentation/MOTP
    ../PTFC_Cfg/Presentation/MOTP/: MOTP_cbk.h MOTP_cfgIf.h MOTP_config.c MOTP_config.h
  group PTFC_Cfg/Presentation/NETP
    ../PTFC_Cfg/Presentation/NETP/: NETP_cbk.h NETP_cfgIf.h NETP_config.c NETP_config.h
  group PTFC_Cfg/Presentation/SNSP
    ../PTFC_Cfg/Presentation/SNSP/: SNSP_cbk.h SNSP_cfgIf.h SNSP_config.c SNSP_config.h
  group PTFC_Cfg/Presentation/TLRP
    ../PTFC_Cfg/Presentation/TLRP/: TLRP_cfgIf.h TLRP_config.c TLRP_config.h
  group PTFC_Cfg/Presentation/TP
    ../PTFC_Cfg/Presentation/TP/: TP_cfgIf.h TP_config.c TP_config.h
  group PTFC_Cfg/System/ECUIDS
    ../PTFC_Cfg/System/ECUIDS/: ECU_Identification.c ECU_Identification.h
  group PTFC_Cfg/System/LPMS
    ../PTFC_Cfg/System/LPMS/: LPMS_cfgIf.h LPMS_config.c LPMS_config.h
  group PTFC_Cfg/System/LTMS
    ../PTFC_Cfg/System/LTMS/: LTMS_cfgIf.h LTMS_config.c LTMS_config.h
  group PTFC_Cfg/System/SCHDS
    ../PTFC_Cfg/System/SCHDS/: SCHDS_config.h
  group PTFC_Cfg/System/TASK
    ../PTFC_Cfg/System/TASK/: TASK_config.c TASK_config.h
  group PTFC_Core
    ../PTFC_Core/: global.h typedefs.h
  group PTFC_Core/Control
    ../PTFC_Core/Control/: CTRL.c CTRL_if.h CTRL_typedefs.h
  group PTFC_Core/Control/ADCC
    ../PTFC_Core/Control/ADCC/: ADCC.c ADCC.h ADCC_if.h
  group PTFC_Core/Control/DIAC
    ../PTFC_Core/Control/DIAC/: DIAC.c DIAC.h DIAC_if.h
  group PTFC_Core/Control/DIAGC
    ../PTFC_Core/Control/DIAGC/: DIAGC.c DIAGC.h DIAGC_if.h
  group PTFC_Core/Control/DOIFC
    ../PTFC_Core/Control/DOIFC/: DOIFC.c DOIFC.h DOIFC_if.h
  group PTFC_Core/Control/DOVFC
    ../PTFC_Core/Control/DOVFC/: DOVFC.c DOVFC.h DOVFC_if.h
  group PTFC_Core/Control/EEPC
    ../PTFC_Core/Control/EEPC/: EEPC.c EEPC.h EEPC_if.h
  group PTFC_Core/Control/HBRGC
    ../PTFC_Core/Control/HBRGC/: HBRGC.c HBRGC.h HBRGC_if.h
  group PTFC_Core/Control/IPOC
    ../PTFC_Core/Control/IPOC/: IPOC.c IPOC.h IPOC_if.h
  group PTFC_Core/Control/LINC
    ../PTFC_Core/Control/LINC/: LINC.c LINC.h LINC_if.h
  group PTFC_Core/Control/MUXC
    ../PTFC_Core/Control/MUXC/: MUXC.c MUXC.h MUXC_if.h
  group PTFC_Core/Control/PWMC
    ../PTFC_Core/Control/PWMC/: PWMC.c PWMC.h PWMC_if.h
  group PTFC_Core/Driver
    ../PTFC_Core/Driver/: cstartup.s26 DRVD.c DRVD_if.h DRVD_typedefs.h intrinsics.h
  group PTFC_Core/Driver/ADCD
    ../PTFC_Core/Driver/ADCD/: ADCD.c ADCD.h ADCD_if.h
  group PTFC_Core/Driver/CAND
    ../PTFC_Core/Driver/CAND/: CAND.c CAND.h CAND_if.h
  group PTFC_Core/Driver/DIOD
    ../PTFC_Core/Driver/DIOD/: DIOD.c DIOD.h DIOD_if.h
  group PTFC_Core/Driver/ISRD
    ../PTFC_Core/Driver/ISRD/: ISRD.c ISRD.h ISRD_if.h
  group PTFC_Core/Driver/MEMD
    ../PTFC_Core/Driver/MEMD/: MEMD.c MEMD.h MEMD_if.h
  group PTFC_Core/Driver/UARTD
    ../PTFC_Core/Driver/UARTD/: UARTD.c UARTD.h UARTD_if.h
  group PTFC_Core/Presentation
    ../PTFC_Core/Presentation/: PRES.c PRES_if.h PRES_typedefs.h
  group PTFC_Core/Presentation/AVGP
    ../PTFC_Core/Presentation/AVGP/: AVGP.c AVGP.h AVGP_if.h
  group PTFC_Core/Presentation/DDMP
    ../PTFC_Core/Presentation/DDMP/: DDMP.c DDMP.h DDMP_if.h
  group PTFC_Core/Presentation/DINP
    ../PTFC_Core/Presentation/DINP/: DINP.c DINP.h DINP_if.h
  group PTFC_Core/Presentation/EEPP
    ../PTFC_Core/Presentation/EEPP/: EEPP.c EEPP.h EEPP_if.h
  group PTFC_Core/Presentation/FUNP
    ../PTFC_Core/Presentation/FUNP/: FUNP.c FUNP.h FUNP_if.h
  group PTFC_Core/Presentation/FVMP
    ../PTFC_Core/Presentation/FVMP/: FVMP.c FVMP.h FVMP_if.h
  group PTFC_Core/Presentation/LINP
    ../PTFC_Core/Presentation/LINP/: LINP.c LINP.h LINP_if.h
  group PTFC_Core/Presentation/MOTP
    ../PTFC_Core/Presentation/MOTP/: MOTP.c MOTP.h MOTP_if.h
  group PTFC_Core/Presentation/NETP
    ../PTFC_Core/Presentation/NETP/: NETP.c NETP.h NETP_if.h
  group PTFC_Core/Presentation/SNSP
    ../PTFC_Core/Presentation/SNSP/: SNSP.c SNSP.h SNSP_if.h
  group PTFC_Core/Presentation/TLRP
    ../PTFC_Core/Presentation/TLRP/: TLRP.c TLRP.h TLRP_if.h
  group PTFC_Core/Presentation/TP
    ../PTFC_Core/Presentation/TP/: TP.c TP.h TP_if.h
  group PTFC_Core/System
    ../PTFC_Core/System/: jmptable.asm main.c SYSM.c SYSM_if.h SYSM_typedefs.h
  group PTFC_Core/System/LPMS
    ../PTFC_Core/System/LPMS/: LPMS.c LPMS.h LPMS_if.h
  group PTFC_Core/System/LTMS
    ../PTFC_Core/System/LTMS/: LTMS.c LTMS.h LTMS_if.h
  group PTFC_Core/System/Scheduler
    ../PTFC_Core/System/Scheduler/: scheduler.c scheduler.h
  group PTFC_Core/System/TASK
    ../PTFC_Core/System/TASK/: TASK_if.h
